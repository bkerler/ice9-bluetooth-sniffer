options:
  parameters:
    author: B. Kerler
    generate_options: qt_gui
    id: rfnm
    output_language: python
    title: RFNM Samplerate Resampler
  states: {}

blocks:
- name: antenna
  id: variable
  parameters:
    value: '''A'''
  states: {}
- name: bw
  id: variable
  parameters:
    comment: 2483.5 Mhz - 2400 Mhz
    value: (2483.5e6-2400e6)
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2427e6
  states: {}
- name: gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: nyquist
  id: variable
  parameters:
    comment: Max ratio => bw = samplerate / 0.75
    value: bw/samp_rate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 61.44e6*speed
  states: {}
- name: speed
  id: variable
  parameters:
    comment: |-
      Set speed depending on your host capability
      1 = 61.44 Msps
      2 = 122.88 Msps

      1. "mkfifo /tmp/fifo"
      2. "mkfifo /tmp/out.pcap"
      3.  "ice9-bluetooth -f /tmp/fifo -C 32 -v -f /tmp/out.pcap"
      whereas 32 is the target_sample_rate
      4. start gnuradio
      5. "sudo wireshark -k -i /tmp/out.pcap"

      Enjoy !
    value: '1'
  states: {}
- name: target_samp_rate
  id: variable
  parameters:
    value: 32e6
  states: {}
- name: blocks_complex_to_interleaved_char_0
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: '1.0'
    vector_output: 'False'
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/fifo
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/fifo
    type: byte
  states: {state: disabled}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'True'
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: target_samp_rate
    type: complex
  states: {}
- name: pfb_arb_resampler_xxx_0_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: target_samp_rate/samp_rate
    type: ccf
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate)
    interp: int(target_samp_rate)
    type: ccc
  states: {state: disabled}
- name: soapy_custom_source_0_0
  id: soapy_custom_source
  parameters:
    antenna0: antenna
    bandwidth0: bw
    center_freq0: freq
    driver: RFNM
    gain0: gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_custom_source_0_0_0
  id: soapy_custom_source
  parameters:
    antenna0: antenna
    bandwidth0: bw
    center_freq0: freq
    driver: RFNM
    gain0: gain
    samp_rate: samp_rate
    type: sc8
  states: {state: disabled}

connections:
- [blocks_complex_to_interleaved_char_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', rational_resampler_xxx_0, '0']
- [blocks_throttle2_0, '0', blocks_file_sink_0_0, '0']
- [pfb_arb_resampler_xxx_0_0, '0', blocks_throttle2_0, '0']
- [pfb_arb_resampler_xxx_0_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_interleaved_char_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [soapy_custom_source_0_0, '0', pfb_arb_resampler_xxx_0_0, '0']
- [soapy_custom_source_0_0_0, '0', blocks_interleaved_char_to_complex_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-774-gce0c68c0
